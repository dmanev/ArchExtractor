# IAR project TARGET.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 256
  General.GFarHeapSize: 4096
  General.GeneralDeviceSelect: 78F0536_64 78K0 - uPD78F0536_64
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 2
  A78000.ADefines: __STANDARD_MODEL__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f0536_64.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC78000.CCDefines: NDEBUG
  ICC78000.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../EXE/: target_d.d26
  group BUILD/Sources
    ../SOURCES/DAT/: DAT.H DAT_ALA.c DAT_ALA.h DAT_ANA.C DAT_ANA.H DAT_ANA.JIL DAT_ANAP.H DAT_ANAP.JIL dat_apr.c dat_apr.h DAT_BUZ.c DAT_BUZ.h DAT_BUZp.h DAT_BUZx.h DAT_CMN.C DAT_CMN.H DAT_CPU.C DAT_CPU.H DAT_CPU.JIL DAT_CPUP.H DAT_DBK.C DAT_DBK.H DAT_DBK.JIL DAT_DBKP.H DAT_DBKX.H DAT_DEA.C DAT_DEA.H DAT_DEA.JIL DAT_DEAP.H DAT_DIN.C DAT_DIN.H DAT_DIN.JIL DAT_DINP.H DAT_DINP.JIL DAT_DOU.C DAT_DOU.H DAT_DOU.JIL DAT_DOUP.H DAT_DOUP.JIL DAT_EEP.C DAT_EEP.H DAT_EEP.JIL DAT_EEP.XLS DAT_EEPM.XLA DAT_EEPP.H DAT_EEPX.H DAT_KWP.C DAT_KWP.H DAT_PAN.C DAT_PAN.H DAT_PAN.JIL DAT_PEE.C DAT_PEE.GFT DAT_PEE.H DAT_PEE.HGR DAT_PEE.JIL DAT_PEEP.H DAT_PEEX.H DAT_PIN.C DAT_PIN.H DAT_PIN.JIL DAT_PINP.H DAT_POU.C DAT_POU.H DAT_POU.JIL DAT_PWM.C DAT_PWM.H DAT_PWM.JIL DAT_PWMP.H DAT_RBG.c DAT_RBG.h Dat_RF.c DAT_RF.h Dat_RFp.h DAT_SBK.C DAT_SBK.H DAT_SBK.JIL DAT_SBKP.H DAT_SBKX.H DAT_SPD.c DAT_SPD.h DAT_TRP.C DAT_TRP.H dat_trpp.h DAT_VLG.C DAT_VLG.H DATPARAM.H
    ../SOURCES/LIB/: DEFTYPES.H LIB.C LIB.H LIB_IMMO.H LIB_STK.H
    ../SOURCES/LAP/: LAP_AFS.C LAP_AFS.H LAP_AFSP.H LAP_ALA.c LAP_ALA.h LAP_BUZ.c LAP_BUZ.h LAP_CAR.c LAP_CAR.h LAP_DFR.c LAP_DFR.gft LAP_DFR.h LAP_DFR.hgr LAP_DFR.jil LAP_DLK.c LAP_DLK.h LAP_DVP.C LAP_DVP.H LAP_EXL.c LAP_EXL.h LAP_FLI.c LAP_FLI.h LAP_FRW.c LAP_FRW.h LAP_ILL.c LAP_ILL.gft LAP_ILL.h LAP_ILL.hgr LAP_ILL.jil LAP_KWP.C LAP_KWP.H LAP_KWPP.H LAP_LRN.c LAP_LRN.h LAP_PAL.c LAP_PAL.h LAP_RRW.c LAP_RRW.h LAP_SUP.C LAP_SUP.GFT LAP_SUP.H LAP_SUP.HGR LAP_SUP.JIL LAP_SUPP.H LAP_TFC.C LAP_TFC.H LAP_VLD.c LAP_VLD.h
    ../SOURCES/LDB_API/: LDB.H LDB_TOS.H LDBPARAM.H LDBTYPES.H
    ../SOURCES/TOS/: TOS.H TOS.JIL TOS_ALA.C TOS_ALA.H TOS_ALA.JIL TOS_JIL.C TOS_ORD.C TOS_ORD.H TOS_ORD.JIL TOS_SEQ.C TOS_SEQ.H TOS_SEQ.JIL TOS_SIG.C TOS_SIG.H TOS_SIG.JIL TOS_TPO.C TOS_TPO.H TOS_TPO.JIL TOSPARAM.H
  group BUILD/Target
    ../Target/LDB/: intrinsics.h io78f0536_64.h LDB_ALA.c LDB_ALA.h LDB_ANA.C LDB_ANA.H LDB_ANAP.H LDB_BUZ.c LDB_BUZ.h LDB_DIN.C LDB_DIN.H LDB_DINP.H LDB_DOU.C LDB_DOU.H LDB_DOUP.H LDB_EEP.C LDB_EEP.H LDB_EEPP.H LDB_HAR.C LDB_HAR.H LDB_HARP.H LDB_INT.C LDB_INT.H LDB_INTP.C LDB_INTP.H LDB_IOC.C LDB_IOC.H LDB_IOCP.H LDB_KWP.C LDB_KWP.H LDB_PWM.c LDB_PWM.h LDB_REG.H LDB_RF.c LDB_RF.h LDB_RFp.h LDB_SLD.c LDB_SLD.h LDB_SLDp.h LDB_SPD.c LDB_SPD.h LDB_SPI.C LDB_SPI.H LDB_SPIP.H LDB_SUP.C LDB_SUP.H LDB_SUP.S26 LDB_SWI.C LDB_SWI.H LDB_TIM.C LDB_TIM.H LDB_TIMP.C LDB_TIMP.H ldb_trp.c ldb_trp.h ldb_trpp.h
